// 八字映射表 (1950-2050) - 自动生成
// 用于快速获取公历日期对应的八字
// 不要手动修改此文件

#ifndef BAZI_MAPPINGS_H
#define BAZI_MAPPINGS_H

// 五行编码
#define METAL 0  // 金
#define WOOD  1  // 木
#define WATER 2  // 水
#define FIRE  3  // 火
#define EARTH 4  // 土

// 天干字符表
const char* HEAVENLY_STEMS[10] = {"甲", "乙", "丙", "丁", "戊", "己", "庚", "辛", "壬", "癸"};

// 地支字符表
const char* EARTHLY_BRANCHES[12] = {"子", "丑", "寅", "卯", "辰", "巳", "午", "未", "申", "酉", "戌", "亥"};

// 天干到五行的映射
const byte STEM_TO_ELEMENT[10] = {
    1,  // 甲 -> 木
    1,  // 乙 -> 木
    3,  // 丙 -> 火
    3,  // 丁 -> 火
    4,  // 戊 -> 土
    4,  // 己 -> 土
    0,  // 庚 -> 金
    0,  // 辛 -> 金
    2,  // 壬 -> 水
    2,  // 癸 -> 水
};

// 地支中天干的数量
const byte BRANCH_STEM_COUNT[12] = {
    1,  // 子: 癸
    3,  // 丑: 己, 癸, 辛
    3,  // 寅: 甲, 丙, 戊
    1,  // 卯: 乙
    3,  // 辰: 戊, 乙, 癸
    3,  // 巳: 丙, 庚, 戊
    2,  // 午: 丁, 己
    3,  // 未: 己, 丁, 乙
    3,  // 申: 庚, 壬, 戊
    1,  // 酉: 辛
    3,  // 戌: 戊, 辛, 丁
    2,  // 亥: 壬, 甲
};

// 地支中的天干编码
const byte BRANCH_STEMS[12][3] = {
    {9, 255, 255},  // 子: 癸
    {5, 9, 7},  // 丑: 己, 癸, 辛
    {0, 2, 4},  // 寅: 甲, 丙, 戊
    {1, 255, 255},  // 卯: 乙
    {4, 1, 9},  // 辰: 戊, 乙, 癸
    {2, 6, 4},  // 巳: 丙, 庚, 戊
    {3, 5, 255},  // 午: 丁, 己
    {5, 3, 1},  // 未: 己, 丁, 乙
    {6, 8, 4},  // 申: 庚, 壬, 戊
    {7, 255, 255},  // 酉: 辛
    {4, 7, 3},  // 戌: 戊, 辛, 丁
    {8, 0, 255},  // 亥: 壬, 甲
};

// 基准年份(1950)的干支索引 (用于计算其他年份)
#define BASE_YEAR 1950
#define BASE_YEAR_STEM 5  // 己
#define BASE_YEAR_BRANCH 1  // 丑

// 月干支起始值 (根据年干确定)
const byte MONTH_STEM_BASE[10] = {
    0,  // 甲年
    2,  // 乙年
    4,  // 丙年
    6,  // 丁年
    8,  // 戊年
    0,  // 己年
    2,  // 庚年
    4,  // 辛年
    6,  // 壬年
    8,  // 癸年
};

// 立春日期表 (1950-2050)
const byte LICHUN_DAYS[101] = {
    /* 1950 - 1959 */ 4, 4, 5, 4, 4, 4, 5, 4, 4, 4, 
    /* 1960 - 1969 */ 5, 4, 4, 4, 5, 4, 4, 4, 5, 4, 
    /* 1970 - 1979 */ 4, 4, 5, 4, 4, 4, 5, 4, 4, 4, 
    /* 1980 - 1989 */ 5, 4, 4, 4, 4, 4, 4, 4, 4, 4, 
    /* 1990 - 1999 */ 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 
    /* 2000 - 2009 */ 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 
    /* 2010 - 2019 */ 4, 4, 4, 4, 4, 4, 4, 3, 4, 4, 
    /* 2020 - 2029 */ 4, 3, 4, 4, 4, 3, 4, 4, 4, 3, 
    /* 2030 - 2039 */ 4, 4, 4, 3, 4, 4, 4, 3, 4, 4, 
    /* 2040 - 2049 */ 4, 3, 4, 4, 4, 3, 4, 4, 4, 3, 
    /* 2050 - 2059 */ 3
};

// 计算日期到公元原点的天数差函数
// 这是一个简化版的算法，用于计算1900年后的日期
uint32_t dayNumber(uint16_t y, uint8_t m, uint8_t d) {
  // 基于Keith Thompson的算法，简化为仅适用于1900年后
  if (m < 3) {
    y--;
    m += 12;
  }
  return 365 * y + y / 4 - y / 100 + y / 400 + (153 * m - 457) / 5 + d - 306;
}

// 根据天数差计算日柱
void getDayPillar(uint32_t dayNum, uint8_t& stem, uint8_t& branch) {
  // 计算日干支 (参考点: 1900-01-01 是 庚子日)
  stem = (dayNum + 9) % 10;  // 干
  branch = (dayNum + 11) % 12;  // 支
}

// 计算时柱
void getHourPillar(uint8_t hour, uint8_t dayStem, uint8_t& stem, uint8_t& branch) {
  // 将小时转换为时辰 (0-11)
  branch = hour / 2;
  if (hour == 23) branch = 0;  // 23点属于子时

  // 根据日干推算时干
  // 甲己日起甲子时，乙庚日起丙子时，丙辛日起戊子时，丁壬日起庚子时，戊癸日起壬子时
  uint8_t baseHourStem = 0;
  switch(dayStem % 5) {
    case 0: baseHourStem = 0; break;  // 甲己日起甲子时
    case 1: baseHourStem = 2; break;  // 乙庚日起丙子时
    case 2: baseHourStem = 4; break;  // 丙辛日起戊子时
    case 3: baseHourStem = 6; break;  // 丁壬日起庚子时
    case 4: baseHourStem = 8; break;  // 戊癸日起壬子时
  }

  stem = (baseHourStem + branch) % 10;
}

#endif // BAZI_MAPPINGS_H
